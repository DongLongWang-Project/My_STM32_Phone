# Keil uVision project project.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: F:\1_Keil\MDK\Core\ARM\ARMCC\bin\fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,LV_LVGL_H_INCLUDE_SIMPLE,USE_USB_OTG_FS
  c misc: --no-multibyte-chars
  c include: .\Library;.\Start;.\System;.\User;.\FreeRTOS\Library;.\FreeRTOS\portable\MemMang;.\FreeRTOS\portable\RVDS\ARM_CM4F;.\Hardware\LED;.\Hardware\SRAM;.\Hardware\TFTLCD;.\Hardware\USART;.\Hardware\W25QXX;.\Hardware\SD;.\FATFS;.\LVGL\porting;.\LVGL;.\LVGL\src;.\LVGL\src\hal;.\LVGL\demos\widgets\assets;.\LVGL\demos\widgets;.\LVGL\src\misc;.\LVGL\src\extra\libs\png;.\LVGL\src\extra\layouts;.\my_gui;.\MALLOC;.\Hardware\KEY;.\Hardware\DX_WF25;.\my_gui\app_file_sys;.\my_gui\app_net_ass;.\my_gui\app_setting;.\my_gui\app_clock;.\my_gui\app_weather;.\SD\font_w25q;.\SD\Font;.\USB\STM32_USB_OTG_Driver\src;.\USB\STM32_USB_OTG_Driver\inc;.\USB\USB_App;.\USB\STM32_USB_Device_Library\Class\msc\src;.\USB\STM32_USB_Device_Library\Core\src;.\USB\STM32_USB_Device_Library\Class\msc\inc;.\USB\STM32_USB_Device_Library\Core\inc;.\Hardware\OV2640;.\my_gui\app_video;.\Hardware\MAX98357;.\my_gui\app_music
  asm include: .\Hardware;.\Start;.\System;.\User;.\Library
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT6: RAM 0x68000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Objects\project.sct
  group Start
    ./Start/: system_stm32f4xx.c startup_stm32f40_41xxx.s core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group System
    ./System/: Delay.c LVGL_Timer.c
  group Library
    ./Library/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_fsmc.c
  group FATFS
    ./FATFS/: diskio.c ff.c ffsystem.c ffunicode.c fatfs.c
  group FreeRTOS
    ./FreeRTOS/Library/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group LVGL
    ./LVGL/porting/: lv_port_indev.c lv_port_fs.c lv_port_disp.c
    ./LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ./LVGL/src/draw/arm2d/: lv_gpu_arm2d.c
    ./LVGL/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ./LVGL/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ./LVGL/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ./LVGL/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ./LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ./LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ./LVGL/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ./LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ./LVGL/src/extra/layouts/flex/: lv_flex.c
    ./LVGL/src/extra/layouts/grid/: lv_grid.c
    ./LVGL/src/extra/libs/bmp/: lv_bmp.c
    ./LVGL/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ./LVGL/src/extra/libs/freetype/: lv_freetype.c
    ./LVGL/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ./LVGL/src/extra/libs/gif/: gifdec.c lv_gif.c
    ./LVGL/src/extra/libs/png/: lodepng.c lv_png.c
    ./LVGL/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ./LVGL/src/extra/libs/rlottie/: lv_rlottie.c
    ./LVGL/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ./LVGL/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ./LVGL/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ./LVGL/src/extra/others/gridnav/: lv_gridnav.c
    ./LVGL/src/extra/others/ime/: lv_ime_pinyin.c
    ./LVGL/src/extra/others/imgfont/: lv_imgfont.c
    ./LVGL/src/extra/others/monkey/: lv_monkey.c
    ./LVGL/src/extra/others/msg/: lv_msg.c
    ./LVGL/src/extra/others/snapshot/: lv_snapshot.c
    ./LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ./LVGL/src/extra/themes/default/: lv_theme_default.c
    ./LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ./LVGL/src/extra/widgets/win/: lv_win.c
    ./LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ./LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ./LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ./LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ./LVGL/src/extra/widgets/span/: lv_span.c
    ./LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ./LVGL/src/extra/widgets/meter/: lv_meter.c
    ./LVGL/src/extra/widgets/menu/: lv_menu.c
    ./LVGL/src/extra/widgets/list/: lv_list.c
    ./LVGL/src/extra/widgets/led/: lv_led.c
    ./LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ./LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ./LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ./LVGL/src/extra/widgets/chart/: lv_chart.c
    ./LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ./LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ./LVGL/src/extra/: lv_extra.c
    ./LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ./LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ./LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ./LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group USB_Device
    ./USB/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
    ./USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB_OTG
    ./USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_App
    ./USB/USB_App/: usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
  group Font
    ./SD/Font/: Font.c my_font_12.c my_font_16.c my_font_24.c my_font_32.c
  group my_gui
    ./my_gui/: ui_app_language.c ui_main.c ui_widgets.c
    ./my_gui/app_file_sys/: file_img.c file_txt.c ui_app_file.c
    ./my_gui/app_setting/: setting_about.c setting_display.c setting_hotspot.c setting_wifi.c ui_app_setting.c ui_app_setting_config.c
    ./my_gui/app_clock/: ui_app_clock.c ui_app_clock_config.c
    ./my_gui/app_weather/: ui_app_weather.c
    ./my_gui/app_net_ass/: ui_app_net.c
    ./my_gui/app_video/: ui_app_video.c
    ./my_gui/app_music/: ui_app_music.c
  group Hardware
    ./Hardware/LED/: LED.c
    ./Hardware/KEY/: key.c HX1838.c
    ./Hardware/SRAM/: SRAM.c
    ./Hardware/TFTLCD/: TFTLCD.c XPT2046.c
    ./Hardware/USART/: USART1.c
    ./Hardware/W25QXX/: W25Qxx.c
    ./Hardware/SD/: SD.c
    ./Hardware/DX_WF25/: DX_WF25.c
    ./Hardware/: ASRPRO.c
    ./Hardware/OV2640/: OV2640.c
    ./Hardware/MAX98357/: MAX98357A.c
  group Malloc
    ./MALLOC/: malloc.c
  group User
    ./User/: main.c LVGL_Task.c FreeRTOS_Task.c stm32f4xx_it.c stm32f4xx_conf.h FreeRTOS.h FreeRTOSConfig.h
    ./Start/: stm32f4xx.h
    ./LVGL/: lv_conf.h
  group docx
    ./docx/: readme.txt readme.md
