# Keil uVision project project.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: F:\1_Keil\MDK\Core\ARM\ARMCC\bin\fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\Hardware;.\Library;.\Start;.\System;.\User;.\Hardware\LED;.\Hardware\USART;.\Hardware\W25QXX;.\System;.\Hardware\IWDG;.\Hardware\Bootloader;.\Hardware\FLASH;.\Hardware\CRC;.\Hardware\TFTLCD;.\FATFS;.\Hardware\SD
  asm define: STM32F40_41xxx
  asm include: .\Hardware;.\Start;.\System;.\User;.\Library
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Start
    ./Start/: system_stm32f4xx.c startup_stm32f40_41xxx.s core_cm4.h stm32f4xx.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group System
    ./System/: Delay.c
  group Library
    ./Library/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_fsmc.c
  group Hardware
    ./Hardware/LED/: LED.c
    ./Hardware/USART/: USART1.c
    ./Hardware/W25QXX/: W25Qxx.c
    ./Hardware/Bootloader/: bootloarder.c
    ./Hardware/IWDG/: IWDG.c
    ./Hardware/FLASH/: flash.c
    ./Hardware/CRC/: crc.c
    ./Hardware/TFTLCD/: TFTLCD.c
    ./Hardware/SD/: SD.c
  group User
    ./User/: main.c stm32f4xx_it.c stm32f4xx_conf.h
  group FATFS
    ./FATFS/: diskio.c fatfs.c ff.c ffsystem.c ffunicode.c
